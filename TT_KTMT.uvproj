# Keil uVision project TT_KTMT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TT_KTMT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\8051_Lib\libraries-20221022T064321Z-001\libraries
  group Source Group 1
    ./Bai 10/Bai_tap_3/: Bai_tap_3.c
    ../8051_Lib/libraries-20221022T064321Z-001/libraries/: delay.c keypad4x4.c LCD2004.c
